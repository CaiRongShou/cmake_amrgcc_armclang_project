# Keil uVision project project.uvprojx, settings and files
target debug (6190000::V6.19::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: Keil5_disp_size_bar_v0.3.exe
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,__TARGET_FPU_VFP
  c include: ..\app\inc;..\libraries\GD32F4xx_standard_peripheral\Include;..\libraries\CMSIS\GD\GD32F4xx;..\libraries\CMSIS\GD\GD32F4xx\Include;..\module\soft_timer;..\module\ringbuffer;..\USER\bsp\inc;..\user\sys\inc;..\libraries\xprintf\src;..\libraries\lwip-2.1.3;..\libraries\lwip-2.1.3\arch;..\libraries\lwip-2.1.3\src;..\libraries\lwip-2.1.3\src\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\startup\linker_scripts\link.sct
  group APP
    ../app/: main.c gd32f4xx_it.c
  group STARTUP
    ../libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group GD32F4xx_standard_peripheral
    ../libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group MODULE
    ../module/ringbuffer/: ringbuffer.c
    ../module/soft_timer/: soft_timer.c
  group bsp
    ../USER/bsp/: bsp_led.c bsp_sd.c bsp_uart.c spi_flash.c bsp_fmc.c
    ../libraries/xprintf/src/: xprintf.c
    ../user/bsp/: bsp_enet.c
  group sys
    ../user/sys/: sdcard.c
  group LWIP/arch
    ../libraries/lwip-2.1.3/arch/: ethernetif.c
  group LWIP/src
    ../libraries/lwip-2.1.3/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../libraries/lwip-2.1.3/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../libraries/lwip-2.1.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../libraries/lwip-2.1.3/src/netif/: ethernet.c
software components: CMSIS:CORE 5.6.0
